# Repository kaouseisaku/kicad_lib

File README.md:

# kicad_lib

## Files

|Name||
|:--|:--|
|footprint||
|symbol||
|module||

## Modules

|Name||
|:--|:--|
|AC_PowerController||
|ConstantCurrentHBridge||
|I2C_TempSenser||

## KiCad design modules/I2C_TempSenser/I2C_TempSenser.kicad_pcb

Parts:
C101: 105C10; C_0201_0603Metric
C102, C103, C104: 104C6P3; C_0201_0603Metric
FB101: BLM03BX182SN1D; L_0201_0603Metric
R101, R103, R104: 0; R_0201_0603Metric; not fitted
R102, R105: 333C1S20; R_0201_0603Metric
TP101, TP102, TP103, TP104, TP105: P5V; Oval_Pad_1.0x4.0mm
U101: TPS7A2033DQN; Texas_X2SON-4_1x1mm_P0.65mm
U102: P82B715DR; SOIC-8_3.9x4.9mm_P1.27mm
U103: TMP119AIYBGR; Texas_DSBGA-6_0.95x1.488mm_Layout2x3_P0.4mm

Connections:
+3.3V: C103.1, C104.1, R103.2, U101.1 (OUT), U103.B1 (V+)
+5V: C101.1, C102.1, FB101.2, R102.1, R103.1, R105.1, U101.3 (EN), U101.4 (IN), U102.5 (VCC)
/SCL1: R104.2, R105.2, U102.7 (Ly), U103.A2 (SCL)
/SCL2: R104.1, TP103.1, U102.6 (Sy)
/SDA1: R101.2, R102.2, U102.2 (Lx), U103.A1 (SDA)
/SDA2: R101.1, TP104.1, U102.3 (Sx)
GND: C101.2, C102.2, C103.2, C104.2, TP102.1, TP105.1, U101.2 (GND), U101.5 (Pad), U102.4 (GND), U103.B2 (GND), U103.C1 (ADD0)
unnamed: FB101.1, TP101.1

Board: 2 copper layers, 9.0 x 31.2 mm, 18 parts (1 on the bottom side), 8 nets.

## KiCad design modules/AC_PowerController/AC_PowerController.kicad_pcb

Parts:
C101, C102, C105, C107, C108, C109: 104C50; C_0603_1608Metric; MPN/Seeed SKU GRT188R71H104KE13D
C103: OPT; C_Disc_D4.7mm_W2.5mm_P5.00mm; not fitted
C104, C106: 105C50; C_0603_1608Metric; MPN/Seeed SKU GRT188R61H105KE13D
D101, D102: 1SS355VM; D_SOD-323F; MPN/Seeed SKU 1SS355VMTE-17
H101, H102, H103, H104, H105, H106, H107, H108, H109, H110: MountingHole; TestPoint_THTPad_D2.0mm_Drill1.0mm; not fitted
J101: 114020164; SEEEDSTUDIO_114020164; MPN/Seeed SKU 114020164; not fitted
JP101, JP102, JP103, JP104: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
Q101, Q102: IRF640; TO-263-2; MPN/Seeed SKU IRF640NSTRLPBF
R101: 2404C1S4; R_0805_2012Metric; MPN/Seeed SKU RK73H2ATTD2404F
R102: 100C1S10; R_0603_1608Metric; MPN/Seeed SKU RK73B1JTTD100J
R103: 203C1S10; R_0603_1608Metric; MPN/Seeed SKU RK73B1JTTD203J
R104: 732C1S8; R_1206_3216Metric; MPN/Seeed SKU RK73H2BTTD7320F
U101: AMC23C10; SOIC-8_7.5x5.85mm_P1.27mm; MPN/Seeed SKU AMC23C10
U102: TPSI3050QDWZRQ1; DWZ0008A-IPC_A; MPN/Seeed SKU TPSI3050QDWZRQ1

Connections:
/AC_L: H108.1, H109.1
/AC_N: H110.1, Q102.2 (D)
/EN: J101.2, U102.1 (EN)
/VDDM: C101.2, C102.1, R102.1, U102.6 (VDDM)
/ZC1: JP103.1 (A), U101.6 (OUT1)
/ZC2: JP104.1 (A), U101.7 (OUT2)
GND: C106.2, C107.2, C108.2, C109.2, J101.4, R103.2, R104.2, U101.5 (GND2), U102.4 (VSSP)
unnamed: C103.1, D101.2 (A), D102.1 (K), R101.2, U101.2 (INP)
unnamed: H101.1, H103.1
unnamed: H102.1, H104.1
unnamed: H106.1, H107.1
unnamed: J101.1, JP103.2 (B), JP104.2 (B)
unnamed: JP101.1 (A), JP102.1 (A), U102.2 (PXFR)
unnamed: JP101.2 (B), R103.1
unnamed: JP102.2 (B), R104.1
unnamed: H105.1, Q101.2 (D), R101.1
unnamed: Q101.1 (G), Q102.1 (G), U102.8 (VDRV)
unnamed: C101.1, U102.7 (VDDH)
VDD: C106.1, C107.1, C108.1, C109.1, J101.3, U101.8 (VDD2), U102.3 (VDDP)
VDD1: C104.1, C105.1, R102.2, U101.1 (VDD1)
VSSS: C102.2, C103.2, C104.2, C105.2, D101.1 (K), D102.2 (A), Q101.3 (S), Q102.3 (S), U101.3 (INN), U101.4 (GND1), U102.5 (VSSS)

Notes on the sheet:
AC inlet : RPE-2010 AC outlet : AC-G07FB18 Rocker SW : JW-S11RKK 7セグドライバ : TM1637 7セグ : HDSP-H5G1
LOAD
FUSE
AC100V

Board: 2 copper layers, 34 parts (0 on the bottom side), 21 nets.

## KiCad design modules/I2C_Expander/I2C_Expander.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 55 parts (0 on the bottom side), 23 nets.

Parts:
C101, C102, C103, C104, C105, C107, C109, C111, C113, C115: 104C10; C_0201_0603Metric
C106, C108, C110, C112, C114: 105C10; C_0201_0603Metric
J101, J102, J103, J104, J105: 114020164; SEEEDSTUDIO_114020164
R101, R103, R107, R108, R113, R116, R121, R122: 102C1S20; R_0201_0603Metric
R102, R104, R105, R106, R109, R110, R111, R114: 333C1S20; R_0201_0603Metric
R112, R115, R117, R118, R119, R120, R123, R124, R125, R126, R127, R128, R129, R130: 0; R_0201_0603Metric
U101, U103, U104, U105: P82B715DR; SOIC-8_3.9x4.9mm_P1.27mm
U102: TCA9544APWR; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
/SCL: J102.1, U102.18 (SCL)
/SCL00: R102.2, R123.2, U101.3 (Sx), U102.6 (SC0)
/SCL01: R105.2, R125.2, U102.9 (SC1), U103.3 (Sx)
/SCL02: R109.2, R127.2, U102.13 (SC2), U104.3 (Sx)
/SCL03: R111.2, R129.2, U102.16 (SC3), U105.3 (Sx)
/SCL10: J101.1, R101.2, R123.1, U101.2 (Lx)
/SCL11: J103.1, R107.2, R125.1, U103.2 (Lx)
/SCL12: J104.1, R113.2, R127.1, U104.2 (Lx)
/SCL13: J105.1, R121.2, R129.1, U105.2 (Lx)
/SDA: J102.2, U102.19 (SDA)
/SDA00: R104.2, R124.2, U101.6 (Sy), U102.5 (SD0)
/SDA01: R106.2, R126.2, U102.8 (SD1), U103.6 (Sy)
/SDA02: R110.2, R128.2, U102.12 (SD2), U104.6 (Sy)
/SDA03: R114.2, R130.2, U102.15 (SD3), U105.6 (Sy)
/SDA10: J101.2, R103.2, R124.1, U101.7 (Ly)
/SDA11: J103.2, R108.2, R126.1, U103.7 (Ly)
/SDA12: J104.2, R116.2, R128.1, U104.7 (Ly)
/SDA13: J105.2, R122.2, R130.1, U105.7 (Ly)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, J101.4, J102.4, J103.4, J104.4, J105.4, R115.2, R118.2, R120.2, U101.4 (GND), U102.10 (GND), U103.4 (GND), U104.4 (GND), U105.4 (GND)
unnamed: R119.1, R120.1, U102.1 (A0)
unnamed: R117.1, R118.1, U102.2 (A1)
unnamed: R112.1, R115.1, U102.3 (A2)
VCC: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, J101.3, J102.3, J103.3, J104.3, J105.3, R101.1, R102.1, R103.1, R104.1, R105.1, R106.1, R107.1, R108.1, R109.1, R110.1, R111.1, R112.2, R113.1, R114.1, R116.1, R117.2, R119.2, R121.1, R122.1, U101.5 (VCC), U102.20 (VCC), U103.5 (VCC), U104.5 (VCC), U105.5 (VCC)

## KiCad design modules/ConstantCurrentHBridge/ConstantCurrentHBridge.kicad_pcb

Parts:
C1, C2: 474C25; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 105C25; C_Disc_D5.0mm_W2.5mm_P5.00mm
D2: D_Zener; D_A-405_P2.54mm_Vertical_AnodeUp
J1, J8: ML-40-S1BYF-2P
J9, J10: TB111-2-2-E-1-1; TerminalBlock_bornier-2_P5.08mm
Q1, Q3: 2SJ334; TO-3P-3_Vertical
Q2, Q4, Q5: 2SK2232; TO-3P-3_Vertical
R1, R2, R3, R4, R6, R12, R13: 103C1S4; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 223C1S4; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: GR-10W 0R1; R_Axial_Power_L20.0mm_W6.4mm_P25.40mm
RV1: 3296W-1-103LF; Potentiometer_Bourns_3296W_Vertical
U1: LM358; DIP-8_W7.62mm

Connections:
/HN1: J10.1, Q4.1 (G), R2.1
/HN2: J10.2, Q2.1 (G), R4.1
/HP1: J9.1, Q3.1 (G), R1.2
/HP2: J9.2, Q1.1 (G), R3.2
GND: C1.2, C2.2, C3.2, D2.1 (K), D2.2 (A), J8.2, R7.1, R13.2, RV1.3, U1.4 (V-)
unnamed: J1.1, Q3.2 (D), Q4.2 (D)
unnamed: J1.2, Q1.2 (D), Q2.2 (D)
unnamed: Q2.3 (S), Q4.3 (S), Q5.2 (D), R2.2, R4.2
unnamed: Q5.1 (G), R5.2
unnamed: Q5.3 (S), R6.2, R7.2
unnamed: R5.1, U1.1
unnamed: RV1.2, U1.3 (+)
unnamed: R6.1, U1.2 (-)
unnamed: R12.2, R13.1, U1.5 (+)
unnamed: U1.6 (-), U1.7
VCC: C1.1, C2.1, C3.1, J8.1, Q1.3 (S), Q3.3 (S), R1.1, R3.1, R12.1, RV1.1, U1.8 (V+)

Notes on the sheet:
Select limit current
0.1Ω
I = 6A
10kΩ

Board: 2 copper layers, 24 parts (0 on the bottom side), 16 nets, no tracks yet.

## KiCad design modules/TUHS/TUHS.kicad_pcb

Board: 2 copper layers, 4 parts (0 on the bottom side), 7 nets, no tracks yet.

Parts:
FL101: SU10VFC-R04250
FL102: SS11VL-R05350
U101: TUHS5Fxx; TUHS3_TUHS5
U102: TUHS25Fxx; TUHS25

Connections:
+5V: U101.4 (-Vout), U102.4 (-Vout)
/N: FL101.1, FL102.1
GND: U101.5 (+Vout), U102.5 (+Vout)
unnamed: FL101.3, U101.2 (AC1)
unnamed: FL101.4, U101.3 (AC2)
unnamed: FL102.3, U102.2 (AC1)
unnamed: FL102.4, U102.3 (AC2)

## KiCad design modules/RPiPico/RPiPico.kicad_pcb

Parts:
C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C118: 104C16; C_0201_0603Metric; MPN/Seeed SKU GRM033C81C104KE14D
C114, C115: 106C50; C_0603_1608Metric; MPN/Seeed SKU GRT188R61H105KE13D
C116, C117: 105C16; C_0201_0603Metric; MPN/Seeed SKU GRM033R61C105ME15D
C119, C120: 270C16; C_0201_0603Metric; MPN/Seeed SKU GRM0335C1H270JA01D
J100, J101, J103: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J102: 10103594-0001LF; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal; MPN/Seeed SKU 10103594-0001LF
J104: Conn_01x03_Pin; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
R101: 0; R_0603_1608Metric; MPN/Seeed SKU RK73Z1JTTD
R102, R103: 27R4C1S16; R_0402_1005Metric; MPN/Seeed SKU RC0402FR-0727R4L
R104: DNF; R_0603_1608Metric; not fitted
R105, R106: 102C1S8; R_0603_1608Metric; MPN/Seeed SKU RK73B1JTTD102J
TP102, TP103: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
U101: TPS3430WDRC; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm
U102: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U103: TPD2E2U06; SOT-553
U104: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U105: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U106: TCA9544A; TSSOP-20_4.4x6.5mm_P0.65mm
U107: LM66200DCK; SOT-583-8
Y101: ABLS-12.000MHZ-20-B4Y-T; Crystal_SMD_HC49-SD

Connections:
+1V1: C105.1, C106.1, C116.1, U104.23 (DVDD), U104.45 (VREG_VOUT), U104.50 (DVDD)
+3.3V: C101.1, C102.1, C103.1, C104.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C115.1, C117.1, C118.1, R101.2, R104.2, TP102.1, U101.1 (VDD1), U101.3 (SET0), U101.6 (SET1), U101.10 (VDD2), U102.2 (VO), U104.1 (IOVDD), U104.10 (IOVDD), U104.22 (IOVDD), U104.33 (IOVDD), U104.42 (IOVDD), U104.43 (ADC_AVDD), U104.44 (VREG_IN), U104.48 (USB_VDD), U104.49 (IOVDD), U105.8 (VCC)
+5V: C114.1, TP103.1, U102.3 (VI), U107.2 (VOUT), U107.7 (VOUT)
/QSPI_SCLK: U104.52 (QSPI_SCLK), U105.6 (CLK)
/QSPI_SD1: U104.55 (QSPI_SD1), U105.5 (DI(IO0))
/QSPI_SD2: U104.54 (QSPI_SD2), U105.3 (IO2)
/QSPI_SD3: U104.51 (QSPI_SD3), U105.7 (IO3)
/QSPI_SDO: U104.53 (QSPI_SD0), U105.2 (DO(IO1))
/QSPI_SS: R104.1, R105.2, U104.56 (QSPI_SS), U105.1 (~CS)
/RUN: J101.2, R101.1, U104.26 (RUN)
/SWCLK: J104.1, U104.24 (SWCLK)
/SWD: J104.3, U104.25 (SWD)
/USB_DN: R103.2, U104.46 (USB_DM)
/USB_DP: R102.2, U104.47 (USB_DP)
/WDI: U101.7 (WDI), U104.27 (GPIO16)
/XIN: C119.2, U104.20 (XIN), Y101.2
/XOUT: R106.1, U104.21 (XOUT)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.1, C120.1, J100.2, J102.5 (GND), J102.6 (Shield), J103.2, J104.2, TP102.2, TP103.2, U101.5 (GND), U101.11 (GND), U102.1 (GND), U103.4, U104.19 (TESTEN), U104.57 (GND), U105.4 (GND), U107.1 (GND), U107.4 (~ON), U107.5 (GND)
unnamed: C120.2, R106.2, Y101.1
unnamed: J101.1, U101.8 (~WDO)
unnamed: J102.3 (D+), R102.1, U103.3
unnamed: J102.2 (D-), R103.1, U103.5
unnamed: J103.1, R105.1
VBUS: J102.1 (VBUS), U107.6 (VIN2)
VIN: J100.1, U107.3 (VIN1)

Notes on the sheet:
USB BOOT
DBG
WDT EN

Board: 2 copper layers, 40 parts (0 on the bottom side), 25 nets.

## Commit log

2025-07-31 feat: start
